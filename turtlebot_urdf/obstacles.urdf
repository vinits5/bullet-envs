Commit message: data log updated in train.py, params file stored in log, steps reduced and mass increased for obstacles

File: turtlebot_urdf/obstacles.urdf (robot description, URDF)
Before this commit: robot obstacles, 1 links, 0 joints
Links:
- link base_link: mass 10 -> 100

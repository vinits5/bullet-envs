Commit message: Obstacle detection added

File: snake/block.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: mass 1.0 -> 200.0
